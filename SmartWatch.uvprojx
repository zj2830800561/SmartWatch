# Keil uVision project SmartWatch.uvprojx, settings and files
target SmartWatch (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartWatch
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\CMSIS\Include;.\USER\inc;.\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: startup_stm32f411xe.s stm32f4xx_it.c system_stm32f4xx.c stm32f4xx.h
  group USER
    ./USER/src/: main.c led.c key.c uart.c adc.c spi.c oled.c timer.c font.c iic.c sht20.c hp6.c hp6_iic.c
    ./USER/inc/: includes.h
  group LIB
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_adc.c
